# Repository ilovelilli/quadbm1387

File README.md:

Schematic and layout in been updated to kicad 9 PCB for a quad bm1387 standalone miner
// skip if deemed off topic!
// Other versions made<b
// A single BM1391 version, obsolete as information on the asic is too scarce
// aSiNine Pharaonis: dual BM1387 version, compatible with the quad version (this)
// Unnamed project single BM1397 (in pre-alpha stage, pcb's are on the slow boat from China)

Motivation:
i have been interested on making a usb miner for home lotery mining using the bm1387 and hopefully other older asic chips with modem interface 
Properties (concept):
- Standalone miner to be connected to a mining pool or a private Bitcoin node that will serve the work (over websocket)
- Size: 80x60mm
- Programmable Vcore for the bm1387 asics
- ws2812 led for special effects ;)
- max. power usage targeted at ~10-15W
- Cooling: M.2 SSD cooler, tie-wrapped to the board with 5V fan.
- Low(est) cost possible!

Major parts used:
- 4x BM1387xx asics (tested bm1387bf & bm1387b)
- ESP32-C3-mini-1
- SY8208A or B step down regulator (8A) <s>(currently controlled by PWM, considering a cheap ($0.10) DAC)</s> controlled by a dac.
- XC6206P-18 lin. regulators for 1.8 & 0.8V
- SY8009B step down regulator (overkill) for the esp32c3, limiting the power supply to 5V only..
- usb-c connector for power (5V) and debugging 

todo: 
- redesign the power to use usb-c 12v to conected to some mosfets with a proper power managment ic 
- make a version but using 4 x bm1385 asic's
- build the firmware for the esp

## KiCad design quad87.kicad_pcb

Parts:
C1, C2, C3: C-EUC0402; C0402
C4, C5, C6, C7, C10, C11, C12, C13, C24, C31, C32: 100nF; C0603
C8, C9: 12pF; C0402
C14, C15, C16, C17: 100nF; C0402
C18, C19, C20, C21, C28: 1uF; C0603
C22, C23: C-EUC1210K; C1210K
C25: 2.2uF; C0603
C26, C27: C-EUC0805; C0805
C29, C30: 10uF; C0603
C34: 1000uF/16V; TT5D10
D1: WS2812_5050; WS2812-5X5-4PIN
ESP32C3-MINI-1: ESP32-C3-MINI-1; ESP32C3MINI
H1, H2, H3, H4: MOUNT-HOLE3.2; 3,2
IO4, IO5, IO9: TPB1,27; B1,27
JPA0: SOLDERJUMPER
JPB0: SOLDERJUMPER
L1: 4.7uH; L0420
L2: 0.68uH; L0630
Q1: FA-20H
R1: 1M; R0402
R2, R3: 10k; R0402
R4, R5, R6, R7, R8, R12: 1k; R0603
R9: 4.7; R0603
R10: 3.3; R0603
R11: 2.2; R0603
R13: 12k; R0603
R14, R19, R20, R21: R-EU_R2010; R2010
R15: 120k NO BOM; R0603
R16, R22: 5k1; R0402
R17: 33k3; R0603
R18: 4k7; R0603
R23: 100k; R0603
R24: 22k; R0603
R25, R26: 10k; R0603
R27, R29, R31, R33: 47; R0402
R28, R30, R32, R34: 51; R0402
R35: 2k2; R0603
R36: NO BOM; R0603
T1: BC847; SOT23
U$1, U$2, U$3, U$4: BM1387A; BM1391
U$5, U$6, U$7, U$8: XC6206P-18; SOT23
U$9, U$10, U$11, U$12: SS26
U$13: SY8208
U$15: 4k7; R0603
U$16: USBCTHT; USBCSMTTHT
U$17: SY8009B; SOT23-6
U$19: SMDSW6X3; SW6X3
U$20, U$21, U$22, U$23, U$24, U$25, U$26, U$28, U$29, U$30, U$31, U$32: SOLDERJUMPER

Connections:
CI: R4.2, R5.1, U$1.P$26 (26-CI)
D+: ESP32C3-MINI-1.P$27, U$16.P$205A6 (P$6A6), U$16.P$208B6 (P$7B6)
D-: ESP32C3-MINI-1.P$26, U$16.P$204B7 (P$5B7), U$16.P$206A7 (P$4A7)
DATIN: ESP32C3-MINI-1.P$31, R5.2
DATOUT: ESP32C3-MINI-1.P$30, R8.1, T1.3 (C)
EN: C31.2, ESP32C3-MINI-1.P$8, R25.1, U$19.P$2
ENABLE: ESP32C3-MINI-1.P$21, U$13.P$1 (EN)
FB: JPA0.P$1, JPB0.P$1, R12.1, R13.2, R15.1, R17.2, R36.1
GND: C7.1, C8.1, C9.1, C10.2, C14.2, C18.1, C22.2, C23.2, C25.2, C26.2, C27.2, C28.2, C29.1, C30.1, C31.1, C32.2, C34.-, D1.GND, ESP32C3-MINI-1.P$1, ESP32C3-MINI-1.P$2, ESP32C3-MINI-1.P$11, ESP32C3-MINI-1.P$36, ESP32C3-MINI-1.P$37, ESP32C3-MINI-1.P$38, ESP32C3-MINI-1.P$39, ESP32C3-MINI-1.P$40, ESP32C3-MINI-1.P$41, ESP32C3-MINI-1.P$42, ESP32C3-MINI-1.P$43, ESP32C3-MINI-1.P$44, ESP32C3-MINI-1.P$45, ESP32C3-MINI-1.P$46, ESP32C3-MINI-1.P$47, ESP32C3-MINI-1.P$48, ESP32C3-MINI-1.P$49, ESP32C3-MINI-1.P$50, ESP32C3-MINI-1.P$51, ESP32C3-MINI-1.P$52, ESP32C3-MINI-1.P$53, ESP32C3-MINI-1.P$54, ESP32C3-MINI-1.P$55, ESP32C3-MINI-1.P$56, ESP32C3-MINI-1.P$57, ESP32C3-MINI-1.P$58, ESP32C3-MINI-1.P$59, ESP32C3-MINI-1.P$60, ESP32C3-MINI-1.P$61, R2.1, R4.1, R11.2, R13.1, R16.2, R22.2, R24.1, R33.2, U$1.P$3 (RI_A-3), U$1.P$7 (PLL_VSS-7), U$1.P$19 (19-TEST), U$1.P$20 (20-ADDR0), U$1.P$21 (21-ADDR1), U$1.P$22 (22-ADDR2), U$1.P$23 (23-ADDR3), U$1.P$29 (29-BI), U$1.P$34 (33-GNDX), U$5.1 (VSS), U$9.P$2 (C), U$13.P$9 (GND), U$16.P$13, U$16.P$14, U$16.P$15, U$16.P$16, U$16.P$200A1B12 (P$10A1B12), U$16.P$212B1A12 (P$13A12B1), U$17.2 (GND), U$19.P$1
IO2: ESP32C3-MINI-1.P$5, R26.2
IO10: D1.DI, ESP32C3-MINI-1.P$16
unnamed: U$2.P$31 (31-RST_N), U$29.P$1
unnamed: U$3.P$31 (31-RST_N), U$24.P$1
unnamed: U$2.P$29 (29-BI), U$30.P$1
unnamed: U$3.P$29 (29-BI), U$25.P$1
unnamed: U$2.P$28 (28-RO), U$31.P$1
unnamed: U$3.P$28 (28-RO), U$26.P$1
unnamed: U$2.P$26 (26-CI), U$32.P$1
unnamed: U$3.P$26 (26-CI), U$28.P$1
unnamed: C1.1, U$1.P$6 (CLKO-6)
unnamed: C1.2, U$2.P$24 (24-XIN)
unnamed: C2.1, U$2.P$6 (CLKO-6)
unnamed: C2.2, U$3.P$24 (24-XIN)
unnamed: U$4.P$31 (31-RST_N), U$20.P$1
unnamed: U$4.P$29 (29-BI), U$21.P$1
unnamed: U$4.P$28 (28-RO), U$22.P$1
unnamed: U$4.P$26 (26-CI), U$23.P$1
unnamed: C3.1, U$3.P$6 (CLKO-6)
unnamed: C3.2, U$4.P$24 (24-XIN)
unnamed: C8.2, Q1.1, R1.2, U$1.P$25 (25-XOUT)
unnamed: C9.2, Q1.3, R1.1, U$1.P$24 (24-XIN)
unnamed: R16.1, U$16.P$210B5 (P$3B5)
unnamed: R22.1, U$16.P$203A5 (P$2A5)
unnamed: L1.P$2 (2), U$17.3 (LX)
unnamed: R23.2, R24.2, U$17.6 (FB)
unnamed: R2.2, R3.1, U$1.P$31 (31-RST_N)
unnamed: R6.1, T1.1 (B)
unnamed: R12.2, R35.1, R36.2
unnamed: C14.1, R33.1, R34.1, U$1.P$8 (PLL_VDD-8), U$1.P$9 (VDDIO-9)
unnamed: C15.1, R31.1, R32.1, U$2.P$8 (PLL_VDD-8), U$2.P$9 (VDDIO-9)
unnamed: C17.1, R27.1, R28.1, U$4.P$8 (PLL_VDD-8), U$4.P$9 (VDDIO-9)
unnamed: U$4.P$4 (RI-4), U$15.1
unnamed: JPA0.P$2, U$13.P$4 (FB)
unnamed: C24.1, L2.P$1 (1), U$13.P$10 (LX)
unnamed: C24.2, U$13.P$6 (BS)
unnamed: ESP32C3-MINI-1.P$18, IO4.TP
unnamed: C28.1, R17.1, R18.2
unnamed: ESP32C3-MINI-1.P$19, IO5.TP
unnamed: ESP32C3-MINI-1.P$23, IO9.TP
unnamed: U$3.P$1 (NRSTO-1), U$20.P$2
unnamed: U$3.P$2 (BO-2), U$21.P$2
unnamed: U$3.P$4 (RI-4), U$22.P$2
unnamed: U$3.P$5 (CO-5), U$23.P$2
unnamed: U$2.P$1 (NRSTO-1), U$24.P$2
unnamed: U$2.P$2 (BO-2), U$25.P$2
unnamed: U$2.P$4 (RI-4), U$26.P$2
unnamed: U$2.P$5 (CO-5), U$28.P$2
unnamed: U$1.P$1 (NRSTO-1), U$29.P$2
unnamed: U$1.P$2 (BO-2), U$30.P$2
unnamed: U$1.P$4 (RI-4), U$31.P$2
unnamed: U$1.P$5 (CO-5), U$32.P$2
unnamed: C16.1, R29.1, R30.1, U$3.P$8 (PLL_VDD-8), U$3.P$9 (VDDIO-9)
NRST: ESP32C3-MINI-1.P$12, R3.2
P3: JPB0.P$2, U$13.P$3 (ILMT)
PWM: ESP32C3-MINI-1.P$22, R18.1
RO: R7.1, T1.2 (E), U$1.P$28 (28-RO)
VCC_1: C4.1, C11.2, C15.2, C18.2, C19.1, R10.2, R11.1, R31.2, U$1.P$33 (34-VDDX), U$2.P$3 (RI_A-3), U$2.P$7 (PLL_VSS-7), U$2.P$19 (19-TEST), U$2.P$20 (20-ADDR0), U$2.P$21 (21-ADDR1), U$2.P$22 (22-ADDR2), U$2.P$23 (23-ADDR3), U$2.P$34 (33-GNDX), U$6.1 (VSS), U$9.P$1 (A), U$10.P$2 (C)
VCC_2: C5.1, C12.2, C16.2, C19.2, C20.1, R9.2, R10.1, R29.2, U$2.P$33 (34-VDDX), U$3.P$3 (RI_A-3), U$3.P$7 (PLL_VSS-7), U$3.P$19 (19-TEST), U$3.P$20 (20-ADDR0), U$3.P$21 (21-ADDR1), U$3.P$22 (22-ADDR2), U$3.P$23 (23-ADDR3), U$3.P$34 (33-GNDX), U$7.1 (VSS), U$10.P$1 (A), U$11.P$2 (C)
VCC_3: C6.1, C13.2, C17.2, C20.2, C21.1, R9.1, R27.2, U$3.P$33 (34-VDDX), U$4.P$3 (RI_A-3), U$4.P$7 (PLL_VSS-7), U$4.P$19 (19-TEST), U$4.P$20 (20-ADDR0), U$4.P$21 (21-ADDR1), U$4.P$22 (22-ADDR2), U$4.P$23 (23-ADDR3), U$4.P$34 (33-GNDX), U$8.1 (VSS), U$11.P$1 (A), U$12.P$2 (C)
VCC_4: C21.2, R14.2, R19.2, R20.2, R21.2, U$4.P$33 (34-VDDX), U$12.P$1 (A)
VCORE: C22.1, C23.1, L2.P$2 (2), R14.1, R19.1, R20.1, R21.1, R35.2
VDD5: C4.2, C5.2, C6.2, C7.2, C26.1, C27.1, C29.2, C32.1, C34.+, D1.VCC, U$5.3 (VIN), U$6.3 (VIN), U$7.3 (VIN), U$8.3 (VIN), U$13.P$7 (IN), U$13.P$8 (INB), U$16.P$201A4B9 (P$12A4B9), U$16.P$211B4A9 (P$1A9B4), U$17.1 (EN), U$17.4 (IN)
VDD33: C30.2, ESP32C3-MINI-1.P$3, L1.P$1 (1), R8.2, R23.1, R25.2, R26.1
VDD33I: C25.1, R15.2, U$13.P$5 (VCC)
VDDIO18_1: C10.1, R6.2, R7.2, R34.2, U$1.P$11 (LDO18I-11), U$1.P$12 (VDDIO18-12), U$1.P$27 (27-CI_A), U$1.P$30 (30-BI_A), U$1.P$32 (32-NRST_A), U$5.2 (VOUT)
VDDIO18_2: C11.1, R32.2, U$2.P$11 (LDO18I-11), U$2.P$12 (VDDIO18-12), U$2.P$27 (27-CI_A), U$2.P$30 (30-BI_A), U$2.P$32 (32-NRST_A), U$6.2 (VOUT)
VDDIO18_3: C12.1, R30.2, U$3.P$11 (LDO18I-11), U$3.P$12 (VDDIO18-12), U$3.P$27 (27-CI_A), U$3.P$30 (30-BI_A), U$3.P$32 (32-NRST_A), U$7.2 (VOUT)
VDDIO18_4: C13.1, R28.2, U$4.P$11 (LDO18I-11), U$4.P$12 (VDDIO18-12), U$4.P$27 (27-CI_A), U$4.P$30 (30-BI_A), U$4.P$32 (32-NRST_A), U$8.2 (VOUT), U$15.2

Notes on the sheet:
1..1.4V
JPA
JPB
0.2
AsiNine Pyramid
for SY8208A connect JPA for SY8208B connect JPB

Board: 2 copper layers, 60.0 x 80.0 mm, 113 parts (0 on the bottom side), 78 nets.

## Commit log

2026-03-20 Revise README for updated bm1387 miner details
    Updated README to reflect changes in schematic and layout for the quad bm1387 standalone miner, including new properties and revisions.
